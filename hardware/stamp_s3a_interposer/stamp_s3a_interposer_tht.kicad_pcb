# Repository airpocket-soundman/IchiPing_solist_AI

File README.md:

# IchiPing on Solist-AI

スピーカから 1 発の Ping(PRBS)を鳴らし、1 個のマイクで拾った反響から、3 部屋の窓 3 枚・扉 2 枚の開閉状態 32 通りを当てるエッジ AI。
特徴抽出・推論・その場での学び直し(オンデバイス学習)まで、ROHM Solist-AI 評価ボード(DT-EBML63Q2557 / ML63Q2557)の上で動く。
[IchiPing](https://protopedia.net/prototype/8470)(NXP FRDM-MCXN947 版)を Solist-AI へ移植した作品。

- 作品ページ(ProtoPedia):https://protopedia.net/prototype/8556
- PV(YouTube):https://youtu.be/eih0WZhSuuw
- ROHM EDGE HACK CHALLENGE 2026:https://rehc.jp/

## 結果

| 評価 | 32 クラス分類の正解率 | 14 クラス換算 |
|---|---|---|
| 実機サーベイ(事前学習モデル、2 回) | 100%(32/32、32/32) | 100% |
| 実機サーベイ(現地校正の後) | 100%(32/32) | 100% |
| 学習外のセッション(条件の異なる 4 グループ, PC で実機と同じ計算) | 99.2 / 99.9 / 95.8 / 100% → 平均 98.7% | 100% |

閉じた扉の向こうの状態(音響的には本来聞こえない)も含めて 32 クラスを当てている。保存するパラメータ数は約 4.36 万
(int8 CNN 前段 42,528 + ELM の β 1,024)で、PC 上の理想的な CNN(約 30 万)の約 1/7。

## 構成

| 処理 | 担当 |
|---|---|
| 特徴抽出(2048 点 FFT → 全閉との差分 → 334 次元 int8) | Solist-AI(CPU) |
| int8 CNN 前段(Conv1d 8/16/32 → FC 32) | Solist-AI(CPU) |
| ELM による 32 クラス推論 | Solist-AI(AxlCORE) |
| 現地校正(OS-ELM で β を逐次更新、float32、P・β は FRAM) | Solist-AI(CPU → AxlCORE) |
| TFT 表示・サーボ(PCA9685 + SG90 ×5)・状態管理 | Solist-AI |
| I²S のスピーカ再生・マイク録音、トグル / EXEC の読み取り | M5Stack Stamp-S3A |

Stamp-S3A は、評価ボードに I²S が無く、拡張端子の信号ピンが TFT・I²C・PCA9685 OE で埋まるため、I/O を補うためだけに使う。
詳しい設計判断・経緯・評価ルールは [docs/DEVELOPMENT.md](docs/DEVELOPMENT.md)。

## リポジトリ構成

| パス | 内容 |
|---|---|
| [firmware/IchiPingInference](firmware/IchiPingInference/README.md) | Solist-AI のファーム(推論 / サーベイ / データ採取)、PC 側ツール、書き込み用イメージ |
| [firmware/StampMeasure](firmware/StampMeasure/platformio.ini) | Stamp-S3A のファーム(PRBS 再生・録音・I²C サーバ、PlatformIO) |
| [hardware/stamp_s3a_interposer](hardware/stamp_s3a_interposer/README.md) | Stamp-S3A を載せる中間基板(KiCad)。発注データは [output/](output/jlcpcb/README.md) |
| [sim/](sim/) | 学習・評価スクリプト(モデル生成、固定小数点の特徴計算の参照実装、Sim 段階の検証) |
| [sim_export/](sim_export/README.md) | 完成版モデル・評価結果([solist_ds/](sim_export/solist_ds/README.md))と Sim 段階の成果物 |
| [docs/](docs/) | 開発記録([DEVELOPMENT.md](docs/DEVELOPMENT.md))、端子割り当て([io_allocation.md](docs/io_allocation.md))、配線ガイド([solist_connection.html](docs/solist_connection.html))、部品表([bom_tht.html](docs/bom_tht.html))、実機サーベイ結果([results/](docs/results/))、Sim 段階の検証レポート([index.html](docs/index.html))、作品ページの画像([protopedia/](docs/protopedia/)) |
| [media/](media/README.md) | PV と作品ページの素材(撮影動画・写真・図の原本)、PV の制作条件と再生成スクリプト |
| [samples/](samples/README.md) | 特徴計算の照合用の音声サンプル |

動画と写真の原本(`media/`)は Git LFS で管理している(`git lfs pull`)。

## 使い方(概要)

1. Stamp-S3A に `firmware/StampMeasure` を書き込む(PlatformIO)。
2. Solist-AI に `firmware/IchiPingInference/prebuilt/ichiping_infer.flash.bin` を書き込む(`tools/flash.ps1`)。
3. 電源を入れると全閉を 3 回測って基準にする。トグルで窓・扉を決めて EXEC を押すと推論、EXEC を 2 秒長押しすると現地校正。

ビルド・サーベイ・データ採取の手順は [firmware/IchiPingInference/README.md](firmware/IchiPingInference/README.md)、
モデルの再生成は [sim_export/solist_ds/README.md](sim_export/solist_ds/README.md)。

## KiCad design hardware/stamp_s3a_interposer/stamp_s3a_interposer_tht.kicad_pcb

File hardware/stamp_s3a_interposer/README.md:

# IchiPing Solist-AI / Stamp-S3A 中間基板

KiCad 10用のRev.B試作設計です。Solist-AIを主制御、Stamp-S3AをI2S音響・GPIO補完に使い、外部配線を純正JST XH（公称2.50 mm）へ集約します。

> **起動時の注意:** このPCにはKiCad 8と10が共存していますが、本設計のPCBはKiCad 10形式です。`.kicad_pro`の関連付けからKiCad 8が起動する場合があるため、`C:\Program Files\KiCad\10.0\bin\kicad.exe`からプロジェクトを開いてください。

## 設計ファイル

- `stamp_s3a_interposer_pcba.kicad_pro` / `.kicad_sch` / `.kicad_pcb`: JLCPCB PCBA版
- `stamp_s3a_interposer_tht.kicad_pro` / `.kicad_sch` / `.kicad_pcb`: 手はんだTHT版
- `stamp_s3a_interposer.kicad_sch`: 旧コネクタ接続表（参照用。設計正本ではない）
- `CONNECTIONS.md`: ハーネス製作時の正本
- `BOM.csv`: 版別BOMの索引
- `BOM_PCBA.csv` / `BOM_THT.csv`: JLCPCB実装版／手はんだ版の部品表
- `tools/generate_board.py`: Rev.B初期配置の生成用（手調整済みPCBA/THT正本には実行しない）
- `tools/generate_schematic.py`: parity確認済みPCBA回路図からTHT回路図を再生成し、ERC／PCB parityを検証
- `tools/import_route.py`: Specctra SESの取込みと線幅正規化
- `tools/reroute_tht.py`: 現在のTHT配置を保持し、Stamp-S3A幾何補正後に既存配線だけを除去してDSNを生成
- `tools/compact_tht.py`: THT正本を92 x 69 mmへ縮小し、Stamp-S3A座標とコネクタ向きを保持した再配線用DSNを生成
- `tools/import_ses.py`: FreeroutingのSESを取り込み、分断されたGNDベタをスティッチングビアで接続
- `validate.ps1`: ERC、DRC、Gerber、ドリル、レンダリング
- `package_jlcpcb.ps1`: JLCPCB PCBAへ投入するGerber ZIP、BOM、CPL、検証レポートを`output/jlcpcb/`へ生成
- `package_jlcpcb_tht.ps1`: THT裸基板用のGerber ZIP、手はんだBOM、発注設定、検証レポートを`output/jlcpcb/`へ生成

## 互換性方針

UNO Q基板の**ピン番号と信号順**を維持します。旧基板の外部コネクタは2.54 mmのXH互換品でしたが、本基板はユーザー指定どおり純正JST XH 2.50 mmです。このため旧ハウジングをそのまま挿す機械互換性はありません。`XHP-n`ハウジングでケーブルを作り直し、導線順を同じにします。

例外は次の2点です。

- `J_MIC` pin 2はStamp-S3Aに合わせて3.3 V。UNO Q音響基板の1.8 Vケーブルを無確認で流用しない。
- PCA9685の安全停止用`J_PCA_OE`を追加。従来の`J_SERVO_CTRL` 4極はそのまま維持する。

## 基板構成

- 外形: THT版92 x 69 mm、PCBA版110 x 72 mm。2層、1.6 mm FR-4、1 oz想定
- 外部コネクタ: 純正JST `B?B-XH-A` 垂直THT、2.50 mm
- Solist: 2x7、2.54 mm MILコネクタ。奇数／偶数列の向きとpin 1を現物で照合する
- Stamp-S3A: 通常版S007-V033を左列1x17・1.27 mm雌ソケットと右列1x6・2.54 mm雌ソケットへ搭載。Stamp側に対応ピンを立て、部品面を上向きにする
- Stampソケット: 中間基板上面から見た配置は公式の部品面PinMap(天面図)を180°回転したもの(シルクの「X-MIRRORED」表記は不正確)。USB／アンテナ方向、M1 pad番号、pin 1をシルクで明示する
- THT版のStampソケット正規座標: `J_STAMP_17=(62.9217, 33.1485, 180deg)`、`J_STAMP_6=(47.6817, 25.5285, 180deg)`。列間15.24 mmで、USBは基板上辺の外側、アンテナは基板内側を向く
- 左列は2.54 mm 1x9と偶数接点用1.27 mm部品の樹脂干渉を避けるため、M1-1..17全体を1.27 mmへ置換する
- 入力: Stamp G44=窓a、G2=窓b、G4=窓c、G6=扉AB、G8=扉BC、G10=EXEC_N。Stampが直接読みSolistへ通知する
- 信号線0.20 mm、3.3 V 0.30 mm、共通5 V 1.00 mm以上、clearance 0.20 mm
- F.Cu/B.CuともGNDベタを設け、GNDパッドは低インピーダンス優先で直結する。Stamp antenna直下だけは両面とも銅箔・配線禁止とする
- Servo電源とlogic/audio電源は同一の共通5 Vレール。2個の入力XHは並列で、異なる電源を同時接続しない

## 電源・安全条件

- `J_PWR_LOGIC` / `J_PWR_SERVO`: 同じ安定化5 Vレールへの並列入力。電流分担が必要な場合も同一電源から配線し、別電源を同時接続しない
- 共通5 Vは入力点からservo/C3系とlogic/audio/C1系へ太配線で分岐し、細い信号配線へサーボ電流を流さない
- `JP_STAMP_5V`: 外部5 VでStampを給電するときだけ短絡。StampをPC USBから給電するときは必ず開放
- `AMP_SD`: Stamp G1制御、10 kΩ GND pull-downでreset中shutdown
- `PCA_OE`: Solist P42制御、10 kΩ Stamp 3.3 V pull-upでreset中PWM停止
- `TFT_CS_N`: 10 kΩ Stamp 3.3 V pull-up
- PCA9685 logic VCCとservo V+を混同しない

## JLCPCB PCBAとTHTフォールバック

JLCPCB PCBA向けの第一候補は次のとおりです。

| 機能 | LCSC候補 |
|---|---|
| 10 kΩ | `C25804` |
| 100 nF | `C14663` |
| 33 Ω / 10 kΩ / 100 kΩ | `C23140` / `C25804` / `C25803` |
| JST XH 2P / 3P / 4P / 5P / 6P | `C265283` / `C144394` / `C144395` / `C157991` / `C144397` |
| Stamp左列1.27 mm雌ソケット / module側雄ヘッダ | `C41360907` / `C41360852` |
| Stamp右列1x6・2.54 mm雌ソケット | `C42431861` |

**LCSC番号、在庫、基本／拡張部品区分、最小発注数、実装可否、実部品寸法、pin 1と実装向きは発注直前にJLCPCB Partsで再確認します。** 自動代替は許可せず、CPLの回転と基板シルクを照合します。

ソケットのPCBA調達が難しい場合は、その部品を未実装（DNP）にし、左列には秋月電子の1.27 mm雌ソケット（通販コード`103866`）とStamp側雄ヘッダ（`103865`）を1x17へ切り分けて手はんだします。右列1x6・2.54 mmにも適合ソケットを手はんだするTHT版を用意します。外部JST XHも必要に応じて未実装とし、同じTHT穴へ純正品を手はんだします。PCBA版とTHT版でネット、穴位置、pin 1、ハーネス順は変えません。

`BOM_THT.csv`の秋月調達品には、通販コードに加えて公式商品ページの直接URLを記載しています。価格と在庫は発注時に再確認します。

## 検証状態

2026-09-13にKiCad 10.0.6で確認済みです。

- 回路図ERC: 0 error / 0 warning
- PCB connectivity: 未配線0
- PCB electrical DRC: short、clearance、track/via、courtyard違反0
- 残件: PCBA版にはKiCad標準フットプリント由来のシルクwarningが残る。THT版は発注パッケージ生成時にDRC 0件を必須とする

`powershell -ExecutionPolicy Bypass -File .\validate.ps1`でレポートと製造出力を`build/`へ再生成できます。

## 製造前の停止条件

このRev.Bは回路・ピン割当の試作版です。次を現物で確認するまで発注しません。

1. Solist-AI現物のCN3/CN1名称、2x7コネクタのgender、pin 1位置、嵌合方向
2. Stamp-S3A S007-V033を部品面上向きで載せたときの配置(PinMap の 180° 回転)、左1x17・1.27 mm／右1x6・2.54 mmソケット中心、USB挿抜空間、アンテナ方向、M1 pad 1位置
3. INMP441、MAX98357A、ILI9341、PCA9685各モジュールのメーカー、SKU、revision、端子シルク
4. TFTのVCC/BL電圧、PCA9685のOE端子と既設pull-up、I2C pull-up合成値
5. Stamp USB給電と外部5 Vの同時給電禁止が`JP_STAMP_5V`運用で守れること
6. XHハウジングを作り直した後の全極導通検査とpin 1照合
7. JLCPCB部品在庫、LCSC番号、CPL回転、またはTHT手はんだ版のDNP指定

サーボはUNO Qと同じくPCA9685モジュールch0..4へ接続します。中間基板には個別SG90用XH3を追加していません。

Parts:
C1: 470uF/16V LOGIC; CP_Radial_D10.0mm_P5.00mm
C2: 100nF LOGIC; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3: 1000uF/35V SERVO; CP_Radial_D12.5mm_P5.00mm
C4: 100nF MIC; C_Disc_D5.0mm_W2.5mm_P5.00mm
C5: 10uF AMP; CP_Radial_D5.0mm_P2.00mm
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
JP_STAMP_5V: OPEN WHEN USB POWERS STAMP; PinHeader_1x02_P2.54mm_Vertical
J_AMP_PWR: AMP:SD,GND,5V; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J_AMP_SIG: AMP:LRC,BCLK,DIN,GND; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J_DOOR_AB: DOOR_AB:1=SIG,2=GND; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J_DOOR_BC: DOOR_BC:1=SIG,2=GND; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J_EXEC: EXEC:1=SIG,2=GND; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J_MIC: MIC:GND,3V3,SD,SCK,WS,LR; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J_PCA_OE: PCA:OE,GND; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J_PWR_LOGIC: INPUT:COMMON_5V,GND; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J_PWR_SERVO: INPUT:COMMON_5V,GND; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J_SERVO_5V_OUT: SERVO:COMMON_5V,GND; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J_SERVO_CTRL: PCA:GND,SCL,SDA,3V3; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J_SOLIST: SOLIST_CN3_2x7; PinSocket_2x07_P2.54mm_Vertical
J_STAMP_6: Stamp-S3A_6P_SOCKET; Stamp_S3A_Right_Socket_1x06_P2.54mm
J_STAMP_17: Stamp-S3A_17P_SOCKET; PinSocket_1x17_P1.27mm_Vertical
J_TFT_PWR: TFT:RST,CS,GND,VCC; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J_TFT_SIG: TFT:MISO_NC,BL,SCK,MOSI,DC; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J_WIN_A: WIN_A:1=SIG,2=GND; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J_WIN_B: WIN_B:1=SIG,2=GND; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J_WIN_C: WIN_C:1=SIG,2=GND; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
R1: 33R BCLK_MIC; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 33R BCLK_AMP; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 33R WS_MIC; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 33R WS_AMP; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 33R AMP_DIN; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 10k AMP_SD pull-down; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7: 100k MIC_SD pull-down; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8: 10k PCA_OE pull-up; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9: 10k TFT_CS pull-up; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
+3V3_STAMP: C4.1, J_MIC.2, J_SERVO_CTRL.4, J_STAMP_6.28 (Pin_6), R8.2, R9.2
+5V_LOGIC: C1.1, C2.1, C3.1, C5.1, JP_STAMP_5V.1 (A), J_AMP_PWR.3, J_PWR_LOGIC.1, J_PWR_SERVO.1, J_SERVO_5V_OUT.1, J_TFT_PWR.4, J_TFT_SIG.2
+5V_STAMP: JP_STAMP_5V.2 (B), J_STAMP_17.13
AMP_SD: J_AMP_PWR.1, J_STAMP_17.1, R6.1
EXEC_N: J_EXEC.1, J_STAMP_17.10
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J_AMP_PWR.2, J_AMP_SIG.4, J_DOOR_AB.2, J_DOOR_BC.2, J_EXEC.2, J_MIC.1, J_MIC.6, J_PCA_OE.2, J_PWR_LOGIC.2, J_PWR_SERVO.2, J_SERVO_5V_OUT.2, J_SERVO_CTRL.1, J_SOLIST.2, J_SOLIST.4, J_SOLIST.11, J_SOLIST.13, J_STAMP_6.18 (Pin_1), J_STAMP_17.11, J_TFT_PWR.3, J_WIN_A.2, J_WIN_B.2, J_WIN_C.2, R6.2, R7.2
I2C_SCL: J_SERVO_CTRL.2, J_SOLIST.1, J_STAMP_17.17
I2C_SDA: J_SERVO_CTRL.3, J_SOLIST.3, J_STAMP_17.15
I2S_BCLK_AMP: J_AMP_SIG.2, R2.2
I2S_BCLK_MIC: J_MIC.4, R1.2
I2S_BCLK_SRC: J_STAMP_6.26 (Pin_5), R1.1, R2.1
I2S_DIN_MIC: J_MIC.3, J_STAMP_17.9, R7.1
I2S_DOUT_AMP: J_AMP_SIG.3, R5.2
I2S_DOUT_SRC: J_STAMP_17.7, R5.1
I2S_WS_AMP: J_AMP_SIG.1, R4.2
I2S_WS_MIC: J_MIC.5, R3.2
I2S_WS_SRC: J_STAMP_17.5, R3.1, R4.1
PCA_OE: J_PCA_OE.1, J_SOLIST.10, R8.1
SW_DOOR_AB: J_DOOR_AB.1, J_STAMP_17.6
SW_DOOR_BC: J_DOOR_BC.1, J_STAMP_17.8
SW_WIN_A: J_STAMP_6.24 (Pin_4), J_WIN_A.1
SW_WIN_B: J_STAMP_17.2, J_WIN_B.1
SW_WIN_C: J_STAMP_17.4, J_WIN_C.1
TFT_CS_N: J_SOLIST.14, J_TFT_PWR.2, R9.1
TFT_DC: J_SOLIST.7, J_TFT_SIG.5
TFT_MOSI: J_SOLIST.9, J_TFT_SIG.4
TFT_RST_N: J_SOLIST.6, J_TFT_PWR.1
TFT_SCK: J_SOLIST.12, J_TFT_SIG.3

Notes on the sheet:
1 電源入力 / POWER INPUT
2 ホスト接続 / SOLIST-AI + STAMP-S3A
3 表示・サーボ / TFT SPI + PCA9685 I2C
4 音声I2S / MICROPHONE + AMPLIFIER
5 6点入力 / SIX ACTIVE-LOW INPUTS
6 組立・機能注記 / ASSEMBLY NOTES
XH: pin 1 = +5V_LOGIC, pin 2 = GND
JP_STAMP_5V - REMOVE BEFORE USB POWER
CN3 pins 5 and 8: NC
J_STAMP_6 physical pads
18 GND | 20 G0 NC | 22 EN NC
24 G44/WIN_A | 26 G43/BCLK | 28 3V3
MIRRORED CARRIER SOCKETS
Module component side faces up; compare USB and antenna ends before insertion.
TFT is write-only; MISO pin 1 is NC. Verify module 5 V input/BL rating.
OE defaults HIGH: servo outputs disabled until Solist-AI enables them.
J_MIC pin order: 1 GND | 2 3V3 | 3 SD | 4 BCLK | 5 WS | 6 L/R=GND
MIC PIN 2 = 3.3 V ONLY
AMP signal pin 4 GAIN=GND (12 dB nominal)
ALL XH CONNECTORS: pin 1 = signal, pin 2 = GND
Contact closure = LOW. Enable Stamp internal pull-ups and firmware debounce.
PCA9685 channel map: CH0 WIN_A CH1 WIN_B CH2 WIN_C CH3 DOOR_AB CH4 DOOR_BC
Servo V+ and logic/audio use the common +5V_LOGIC rail; both power-input XH connectors are parallel.
Startup defaults: AMP_SD LOW (R6); PCA_OE HIGH (R8); TFT_CS_N HIGH (R9).
Before fitting modules: measure MIC 3.3 V, PCA logic 3.3 V, AMP 5 V, servo V+ 5 V; verify XH pin 1.
I2C is shared by Solist-AI, Stamp-S3A and PCA9685. Stamp sends input status/events and optional FFT data.
C1 470uF/16V LOGIC
C2 100nF LOGIC
C3 1000uF/35V SERVO
C4 100nF MIC
C5 10uF AMP
R1 33R BCLK_MIC
R2 33R BCLK_AMP
R3 33R WS_MIC
R4 33R WS_AMP
R5 33R AMP_DIN
R6 10k AMP_SD pull-down
R7 100k MIC_SD pull-down
R8 10k PCA_OE pull-up
R9 10k TFT_CS pull-up

Board: 2 copper layers, 92.0 x 69.0 mm, 38 parts (0 on the bottom side), 28 nets.

## Commit log (part)

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2026-06-15 Update IchiPing system diagrams for Solist-AI
